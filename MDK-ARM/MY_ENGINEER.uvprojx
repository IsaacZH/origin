# Keil uVision project MY_ENGINEER.uvprojx, settings and files
target MY_ENGINEER (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MY_ENGINEER +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./USER/drive;./USER/device;./USER/device/Imu;./USER/Alog;./USER/Alog/support;./USER/config;./USER/control;./USER/device/oled;./USER/motor;./USER/my_task;./USER/protocol;./USER/protocol/crc;../Drivers/CMSIS-DSP/Include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Alog
    ./USER/Alog/: ave_filter.c rp_math.c
    ./USER/Alog/support/: math_support.c
  group drive
    ./USER/drive/: drive.c drv_can.c drv_haltick.c drv_io.c drv_tim.c drv_uart.c drv_flash.c
  group motor
    ./USER/motor/: motor.c MOTOR_EXAMPLE.c
  group protocol
    ./USER/protocol/: can_protocol.c remote_protocol.c
    ./USER/protocol/crc/: crc.c
  group config
    ./USER/config/: config_can.c config_uart.c
  group device
    ./USER/device/: device.c remote.c test_motor.c
    ./USER/device/oled/: oled.c
  group control
    ./USER/control/: test.c control.c
  group tasks
    ./USER/my_task/: my_task.c
  group imu
    ./USER/device/Imu/: bmi.c bmi2.c bmi270.c common.c imu_protocol.c imu_sensor.c
  group Drivers/CMSIS-DSP
    ../Drivers/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../Drivers/CMSIS-DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../Drivers/CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../Drivers/CMSIS-DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
software components: CMSIS:CORE 5.6.0
